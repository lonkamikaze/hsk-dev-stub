# Keil uVision project hsk_dev.uvproj, settings and files
target HSK_DEV-STUB (MCS-51)
  device: XC878CM-16FF Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xFBFF) IROM(0-0xEFFF) IROM2(0xF000-0xFFFF) CLOCK(24000000) MOD517DP
  output: hsk_dev-stub +hex
  c flags: Optimize=12 SizeSpeed=1
  c define: __xdata, __pdata, __idata
  c include: ..\..\hsk_libs\src;..\..\CAN\src
  link misc: REMOVEUNUSED
  group DOC
    ../src/doc/: mainpage.txt
  group MAIN
    ../src/: config.h main.c
  group HSK_LIBS::HSK_BOOT
    ../../hsk_libs/src/hsk_boot/: startup.a51 hsk_boot.c
  group HSK_LIBS::HSK_ISR
    ../../hsk_libs/src/hsk_isr/: hsk_isr.c
